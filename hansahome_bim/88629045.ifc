Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-10T12:14:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 10 12:14:27 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\8f93c90a-c7b8-4513-8acb-ad717d5238bc\83a5a99d-f60f-46a1-a8cc-63b6a86a09d7\ifc * Database version: 5507 * Database creation date: Thu Oct 10 12:14:26 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 10 12:14:27 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 10 12:14:27 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 88629045 Cover part for bath and shower faucet, 88629045:88629045 Cover part for bath and shower faucet:503418
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 78.058 mm; NominalHeight: 169.969 mm; NominalWidth: 169.906 mm
Type - General - Author: BIMStone; BIMObjectName: 88629045; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_10; Uniclass2015Description: Bath thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_10; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval ABP: PA-IX 38188/IDD; Approval DVGW: DW-6509CS0197; EAN Number: 4015474279131; EN Standard: EN 1111; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 204 x 186 x 174; UNSPSC Class Number: 30181810 Faucet trim; URL ABP: http://static.hansa.com/ABP/88629045; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/88629045; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL DVGW: http://static.hansa.com/DVGW/88629045; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.hansa.com/EPD/88629045; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/169335_88629045_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/88629045; 3D View: https://static.hansa.com/3D/88629045; Catalog Drawing URL: http://static.hansa.com/catdrw/88629045; Category B2C: Bathtub & Shower; Color variants: 8862904533; Dimension Drawing URL: http://static.hansa.com/dimdrw/88629045; FDV Document URL: http://www.hansa.com/datasheet/88629045/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/88629045; Group: Bath and shower faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/88629045; Interactive AR View URL: https://static.hansa.com/AR/88629045; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/88629045; Model: 88629045 Cover part for bath and shower faucet; Name_en: 88629045 Cover part for bath and shower faucet; OmniClass Number: 23.45.55.00; Product Code: 88629045; Product Family: HANSAHOME; Product Image URL: http://static.hansa.com/image/88629045; Product URL: http://static.hansa.com/88629045; Spare-Part Information URL: http://static.hansa.com/sp/88629045; Technical DataSheet URL: http://www.hansa.com/datasheet/88629045/en; Type Name: 88629045 Cover part for bath and shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Inner body made of DZR brass;Manual, ceramic, pressure independent diverter with volume control and stop function for two outlets; Backflow Prevention EN1717: EB; Concealed Parts: Rosette plate frame;Round rosette;Sleeve;Fastening of the function unit with screws;BLUECLICK for an easy, screwless trim plate installation;BLUETUNE alignment after installation of +/- 3,5º; Diverter: Turn operated diverter; DN Size: 170 mm; Flow Rate At 300kPa: 0.012007 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Thermostatic cartridge for automatic temperature control;Non-return valve(s); Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 88629045; Features: Thermostatic;Trim Kit; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 88629045; Name: 88629045 Cover part for bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 170x85x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 88629045 Cover part for bath and shower faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 88629045; Manufacturer: HANSA
Pset_ProductRequirements - Name: 88629045 Cover part for bath and shower faucet; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0554029 m2; Volume: 0.00225391 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 88629045: 88629045 Cover part for bath and shower faucet; Family and Type: 88629045: 88629045 Cover part for bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 88629045: 88629045 Cover part for bath and shower faucet; Type Id: 88629045: 88629045 Cover part for bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
